options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: rx
    output_language: python
    title: RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 1.8425e9
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: 1.8425e9
    gain0: '40'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 20e6
    center_freq0: 1.8425e9
    dev_args: '""'
    gain0: '50'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
